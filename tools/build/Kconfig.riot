## tools/build/Kconfig.riot
```kconfig
config RIOT
    def_bool y
    select FEATURE_HW_PWM
    select FEATURE_HW_SPI
    select FEATURE_HW_GPIO
    select FEATURE_HW_UART
```
